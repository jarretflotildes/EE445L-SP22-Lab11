# Keil uVision project SegmentExample.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SegmentExample
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c misc: -D__FAST__
  c include: ..\..\..\TM4C;..\..\TM4C123Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Segment
    ../../lib/segment/: segment.c
    ../../lib/shifter/: shifter.c
    ./: SegmentExample.c
  group TM4C123Drivers
    ../../TM4C123Drivers/inc/: startup.s
    ../../TM4C123Drivers/lib/FaultHandler/: FaultHandler.c
    ../../TM4C123Drivers/lib/GPIO/: GPIO.c
    ../../TM4C123Drivers/lib/PLL/: PLL.c
    ../../TM4C123Drivers/lib/Timer/: Timer.c
    ../../TM4C123Drivers/lib/UART/: UART.c
