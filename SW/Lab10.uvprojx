# Keil uVision project Lab10.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5 +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./lib/RGB/: RGB.c LED.h LED.c
    ./inc/: startup.s LaunchPad.c Timer0A.c TExaS.c PLL.c Timer4A.c Timer2A.c Timer1A.c Timer3A.c I2C1.c
    ./lib/IO/: Switches.c
    ./: Switches.h Lab11.c
    ./lib/Sound/: Music.c Sound.c
    ./lib/Accelerometer/: Accelerometer.c
    ./lib/Motion/: Motion.c
