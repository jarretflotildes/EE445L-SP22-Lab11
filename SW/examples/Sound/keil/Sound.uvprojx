# Keil uVision project Sound.uvprojx, settings and files
target RGB (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RGB +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../../../inc/: startup.s PLL.c Timer4A.h Timer4A.c Timer3A.c Timer3A.h Timer1A.h Timer1A.c
    ./: SoundMain.c
    ../../../lib/Sound/: Sound.c Sound.h Sounds.h Music.h Music.c
